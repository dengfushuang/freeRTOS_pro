# Keil uVision project freeRTOS.uvprojx, settings and files
target Target1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freeRTOS_test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\Startup;..\Libraries\Drivers\include;..\FreeRTOS\include;..\FreeRTOS;..\FreeRTOS\portable;..\Hardware\FreeRTOS\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c
  group Libraries
    ../Libraries/Drivers/source/: debug_frmwrk.c lpc177x_8x_adc.c lpc177x_8x_can.c lpc177x_8x_clkpwr.c lpc177x_8x_crc.c lpc177x_8x_dac.c lpc177x_8x_eeprom.c lpc177x_8x_emac.c lpc177x_8x_emc.c lpc177x_8x_exti.c lpc177x_8x_gpdma.c lpc177x_8x_gpio.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_iap.c lpc177x_8x_lcd.c lpc177x_8x_mci.c lpc177x_8x_mcpwm.c lpc177x_8x_nvic.c lpc177x_8x_pinsel.c lpc177x_8x_pwm.c lpc177x_8x_qei.c lpc177x_8x_rtc.c lpc177x_8x_ssp.c lpc177x_8x_systick.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_usbhost.c lpc177x_8x_wwdt.c
  group Startup
    ../Startup/: startup_LPC17xx.s core_cm3.c system_LPC177x_8x.c
  group Hardware
    ../Hardware/FreeRTOS/src/: uart0.c user_queue.c
  group FreeRTOS
    ../FreeRTOS/: heap_1.c list.c queue.c tasks.c croutine.c event_groups.c timers.c
    ../FreeRTOS/portable/: port.c
